options:
  parameters:
    author: Atsushi.N
    generate_options: no_gui
    id: OOK_APCMA_RX
    output_language: python
    title: APCMA_Demodulation
  states: {}

blocks:
- name: Bits_Per_Symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Slot_Length
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Sub_Slot_Rate
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Threshold
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Atsushi.N\Desktop\wav_sink\data1.wav
    repeat: 'True'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math


      class SignalDetection(gr.decim_block):
          def __init__(self, slot_length=128, sub_slot_rate=8, threshold=0.2):
              gr.decim_block.__init__(
                  self,
                  name='Signal Detection',
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32],
                  decim=slot_length/sub_slot_rate)

              self.decim = int(slot_length/sub_slot_rate)
              self.set_relative_rate(sub_slot_rate/slot_length)
              self.threshold = threshold

          def work(self, input_items, output_items):
              tmp = [(abs(input_items[0][i]) > 0.1) or (abs(input_items[1][i]) > 0.1) for i in range(len(input_items[0]))]
              output_items[0][:] = [sum(tmp[i * self.decim:(i + 1) * self.decim]) > self.decim * 0.5 for i in range(len(output_items[0][:]))]
              return len(output_items[0][:])
    slot_length: Slot_Length
    sub_slot_rate: Sub_Slot_Rate
    threshold: Threshold
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Sub_slot_rate: Sub_Slot_Rate
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class PulseDetection(gr.decim_block):
          def __init__(self, Sub_slot_rate=8):
              gr.decim_block.__init__(
                  self,
                  name='Pulse Detection',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
                  decim = Sub_slot_rate)
              self.decim = Sub_slot_rate
              self.set_relative_rate(1.0/Sub_slot_rate)

          def work(self, input_items, output_items):
              output_items[0][:] = [sum(input_items[0][j+self.decim*i] > 0.5 for j in range(self.decim)) > self.decim * 0.5 for i in range(len(output_items[0][:]))]
              return len(output_items[0][:])
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      # -*- coding: utf-8 -*-
      import numpy as np
      from gnuradio import gr


      class ApcmaDecode(gr.sync_block):
          def __init__(self, bits_per_symbol=4):
              gr.sync_block.__init__(
                  self,
                  name='Decoding APCMA',
                  in_sig=[np.float32],
                  out_sig=None
              )

              self.bits_per_symbol = bits_per_symbol  # [bits/symbol]
              self.number_of_slot = 2 ** (self.bits_per_symbol + 1) + 5
              self.ApcmaCode = [[0] * self.number_of_slot for i in range(2 ** self.bits_per_symbol)]
              for i in range(2 ** self.bits_per_symbol):
                  self.ApcmaCode[i][0] = 1
                  self.ApcmaCode[i][i + 2] = 1
                  self.ApcmaCode[i][- i - 3] = 1
                  self.ApcmaCode[i][-1] = 1

              self.PulseList = np.zeros(self.number_of_slot)

          def work(self, input_items, output_items):
              for i in range(len(input_items[0][:])):
                  self.PulseList = np.append(self.PulseList[1:], input_items[0][i])
                  # print(self.PulseList)
                  for j in range(len(self.ApcmaCode)):
                      if np.all(np.logical_and(self.ApcmaCode[j][:], self.PulseList) == self.ApcmaCode[j][:]):
                          # print("Word:{}".format(j + 1))
                          with open('C:\\Users\\Atsushi.N\Desktop\\Output.txt', 'a') as f:
                              f.write(f'{j+1}\n')
              return 0
    bits_per_symbol: Bits_Per_Symbol
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: '924000000'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '10'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', epy_block_0, '1']
- [blocks_file_source_0, '0', blocks_complex_to_float_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
