options:
  parameters:
    author: Atsushi.N
    generate_options: qt_gui
    id: OOK_APCMA_RX
    output_language: python
    title: APCMA_Demodulation
  states: {}

blocks:
- name: Bits_Per_Symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Slot_Length
  id: variable
  parameters:
    value: '400'
  states: {}
- name: Sub_Slot_Rate
  id: variable
  parameters:
    value: '5'
  states: {}
- name: Threshhold
  id: variable
  parameters:
    value: '400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\data.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class signal_detection(gr.decim_block):
          def __init__(self, slot_length=400, sub_slot_rate=5, threshhold=0.1):
              gr.decim_block.__init__(self,
                  name='Signal Detection',
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.float32],
                  decim = slot_length/sub_slot_rate)

              self.decim = int(slot_length/sub_slot_rate)
              self.set_relative_rate(sub_slot_rate/slot_length)
              self.threshhold = threshhold

          def work(self, input_items, output_items):
              tmp = [(abs(input_items[0][i]) > 0.1) or (abs(input_items[1][i]) > 0.1) for i in range(len(input_items[0]))]
              output_items[0][:] = [sum(tmp[i * self.decim:(i + 1) * self.decim]) > self.decim * 0.5 for i in range(len(output_items[0][:]))]
              return len(output_items[0][:])
    slot_length: Slot_Length
    sub_slot_rate: Sub_Slot_Rate
    threshhold: Threshhold
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    Sub_slot_rate: Sub_Slot_Rate
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class pulse_detection(gr.decim_block):
          def __init__(self, Sub_slot_rate=5):
              gr.decim_block.__init__(self,
                  name='Pulse Detection',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
                  decim = 5)
              self.decim = Sub_slot_rate
              self.set_relative_rate(1.0/self.decim)

          def work(self, input_items, output_items):
              output_items[0][:] = [sum(input_items[0][j+self.decim*i] > 0.5 for j in range(self.decim)) >= 3 for i in range(len(output_items[0][:]))]
              return len(output_items[0][:])
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    B: Bits_Per_Symbol
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class APCMA_Decode(gr.sync_block):
          def __init__(self, B=2):
              gr.sync_block.__init__(
                  self,
                  name='Decoding APCMA',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # 復号するために参照するパルス列の作成
              self.B = B # [bits/symbol]
              self.Nslot = 2 ** (self.B + 1) + 5
              self.ApcmaCode = [[0] * self.Nslot for i in range(2 ** self.B)]
              for i in range(2 ** self.B):
                  self.ApcmaCode[i][0] = 1
                  self.ApcmaCode[i][i + 2] = 1
                  self.ApcmaCode[i][- i - 3] = 1
                  self.ApcmaCode[i][-1] = 1

              self.PulseList = np.zeros(self.Nslot)  # 入力されたパルス列のリスト

          def work(self, input_items, output_items):
              for i in range(len(input_items[0][:])):
                  self.PulseList = np.append(self.PulseList[1:], input_items[0][i])
                  print(self.PulseList)
                  for j in range(len(self.ApcmaCode)):
                      if np.all(self.PulseList == self.ApcmaCode[j]):
                          print(f'Word:{j}')
              output_items[0][:] = input_items[0][:]
              return len(output_items[0][:])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', epy_block_1, '0']
- [blocks_wavfile_source_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '1', epy_block_0, '1']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_2, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
