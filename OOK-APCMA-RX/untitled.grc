<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bits_Per_Symbol</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Slot_Length</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sub_Slot_Rate</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Threshhold</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import math

class signal_detection(gr.decim_block):
    def __init__(self, slot_length=400, sub_slot_rate=5, threshhold=0.1):
        gr.decim_block.__init__(self,
            name='Signal Detection',
            in_sig=[np.float32, np.float32],
            out_sig=[np.float32],
            decim = slot_length/sub_slot_rate)

        self.decim = int(slot_length/sub_slot_rate)
        self.set_relative_rate(sub_slot_rate/slot_length)
        self.threshhold = threshhold

    def work(self, input_items, output_items):
        tmp = [(abs(input_items[0][i]) &gt; 0.1) or (abs(input_items[1][i]) &gt; 0.1) for i in range(len(input_items[0]))]
        output_items[0][:] = [sum(tmp[i * self.decim:(i + 1) * self.decim]) &gt; self.decim * 0.5 for i in range(len(output_items[0][:]))]
        # print(output_items[0][:])
        # with open('C:\\Users\\Atsushi.N\\Desktop\\data.csv', 'a') as f:
        #     f.write(output_items)
        return len(output_items[0][:])
</value></param>
<param><key>slot_length</key><value>Slot_Length</value></param>
<param><key>sub_slot_rate</key><value>Sub_Slot_Rate</value></param>
<param><key>threshhold</key><value>Threshhold</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class pulse_detection(gr.decim_block):
    def __init__(self, Sub_slot_rate=5):
        gr.decim_block.__init__(self,
            name='Pulse Detection',
            in_sig=[np.float32],
            out_sig=[np.float32],
            decim = 5)
        self.decim = Sub_slot_rate
        self.set_relative_rate(1.0/self.decim)

    def work(self, input_items, output_items):
        output_items[0][:] = [sum(input_items[0][j+self.decim*i] &gt; 0.5 for j in range(self.decim)) &gt;= 3 for i in range(len(output_items[0][:]))]
        return len(output_items[0][:])
</value></param>
<param><key>Sub_slot_rate</key><value>Sub_Slot_Rate</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_2</value></param>
<param><key>B</key><value>Bits_Per_Symbol</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-
import numpy as np
from gnuradio import gr


class APCMA_Decode(gr.sync_block):
    def __init__(self, B=2):
        gr.sync_block.__init__(
            self,
            name='Decoding APCMA',
            in_sig=[np.float32],
            out_sig=[np.float32]
        )

        self.B = B # [bits/symbol]
        self.Nslot = 2 ** (self.B + 1) + 5
        self.ApcmaCode = [[0] * self.Nslot for i in range(2 ** self.B)]
        for i in range(2 ** self.B):
            self.ApcmaCode[i][0] = 1
            self.ApcmaCode[i][i + 2] = 1
            self.ApcmaCode[i][- i - 3] = 1
            self.ApcmaCode[i][-1] = 1

        self.PulseList = np.zeros(self.Nslot)

    def work(self, input_items, output_items):
        for i in range(len(input_items[0][:])):
            self.PulseList = np.append(self.PulseList[1:], input_items[0][i])
            print(self.PulseList)
            for j in range(len(self.ApcmaCode)):
                if np.all(self.PulseList == self.ApcmaCode[j]):
                    print("Word:{}".format(j+1))
        output_items[0][:] = input_items[0][:]
        return len(output_items[0][:])
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>200000</value></param>
<param><key>center_freq0</key><value>924000000</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>epy_block_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_2</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
