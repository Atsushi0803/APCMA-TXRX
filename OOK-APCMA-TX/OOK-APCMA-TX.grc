options:
  parameters:
    author: Atsushi.N
    generate_options: qt_gui
    id: OOK_APCMA_TX
    output_language: python
    title: OOK-APCMA Transmitter
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interval_slot
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: '400'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: slot_width
  id: variable
  parameters:
    value: '400'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    B: bits_per_symbol
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport csv\nimport random\n\n\n############################### APCMA Transmitter ############################\nclass blk(gr.sync_block):\n    def __init__(self, B=2, pulse_width=400, slot_width=400, interval_slot=50):\n        gr.sync_block.__init__(\n            self,\n            name='APCMA Modulation',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n\n        # pulse_width[sample]   : パルス幅[us]\n        # 100                   : 512\n        # 200                   : 1024\n        # 400                   : 2048\n        # 1600                  : 8192\n        # 各パラメータの決定\n        self.pulse_width = pulse_width  # [sample]\n        self.B = B  # [bit/symbol]\n        self.slot_width = slot_width  # [sample]\n        self.interval_slot = interval_slot  # シンボル間隔のスロット数 [slot]\n\n        self.nslot = 0  # タイムスロットの番号、1:2**self.fs +5\n        self.l = 0\n        self.init_symbol()  # 最初のシンボルを決定\n\n\n    def init_symbol(self):\n        # 送信する値varを決定(1,ランダム; 2,サイクル; 3,固定)\n        # 1,ランダム\n        # var = random.randint(1, 2 ** self.B)  # ランダム\n\n        # 2,サイクル\n        var_list = list(range(1, 2 ** self.B + 1))\n        var = var_list[self.l]\n        self.l += 1\n        if self.l == 2 ** self.B:\n            self.l = 0\n\n        # 3,固定\n        # var = 3\n\n        # 送信した値varを保存\n        # with open('send_data.csv', 'a') as f:\n        #     print(var, file=f)\n        self.slot_ook = [0] * (2 ** (1 + self.B) + 5 + self.interval_slot)\n        on = [0, var+1, 2 ** (1 + self.B) + 3 - var, 2 ** (1 + self.B) + 4]\n        for i in on:\n            self.slot_ook[i] = 1\n        self.nslot = 0\n\n    def work(self, input_items, output_items):\n        if len(output_items[0]) > self.slot_width:\n            output_items[0][:] = np.zeros(len(output_items[0]))\n            if self.slot_ook[self.nslot] == 1:\n                output_items[0][0:self.pulse_width] = 1\n\n            # flagを進める\n            self.nslot = self.nslot + 1\n\n            # 1シンボルを送信したあとの処理\n            if self.nslot == (2 * (2 ** self.B + 1) + self.interval_slot):\n                self.init_symbol()\n\n            return self.slot_width\n        else:\n            return 0\n\n"
    interval_slot: interval_slot
    pulse_width: pulse_width
    slot_width: slot_width
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '50000'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '100000'
    center_freq0: '924000000'
    dev_args: '""'
    gain0: '10'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
