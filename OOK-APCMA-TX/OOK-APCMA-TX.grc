<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>OOK_APCMA_TX</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>OOK-APCMA Trasmitter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bits_per_symbol</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interval_slot</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_per_buffer</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slot_width</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>B</key><value>bits_per_symbol</value></param>
<param><key>_source_code</key><value># -*- coding: utf-8 -*-

import numpy as np
from gnuradio import gr
import csv
import random


############################### APCMA Transmitter ############################
class blk(gr.sync_block):
    def __init__(self, B=2, slot_width=400, interval_slot=50, slot_per_buffer=1):
        gr.sync_block.__init__(
            self,
            name='APCMA Modulation',
            in_sig=None,
            out_sig=[np.complex64]
        )

        self.B = B  # [bit/symbol]
        self.slot_width = slot_width  # [sample]
        self.interval_slot = interval_slot  # シンボル間隔のスロット数 [slot]
        self.slot_per_buffer = slot_per_buffer
        self.slot_per_symbol = 2 ** (1 + self.B) + 5 + self.interval_slot

        self.nslot = 0  # タイムスロットの番号、1:2**self.fs +5
        self.l = 0
        self.slot_ook = [0] * self.slot_per_symbol

        self.init_symbol()

    def decide_var(self, pattern, start_var, end_var):
        if pattern == "random":
            var = random.randint(start_var, end_var)
        elif pattern == "loop":
            var_list = list(range(start_var, end_var + 1))
            var = var_list[self.l]
            self.l += 1
            if self.l == len(var_list):
                self.l = 0
        elif pattern == "static":
            var = start_var

        # 送信した値varを保存
        # with open('send_data.csv', 'a') as f:
        #     print(var, file=f)
        print(var)
        return var

    def init_symbol(self):
        var = self.decide_var("static", 1, 4)
        self.slot_ook = [0] * self.slot_per_symbol
        on = [0, var + 1, 2 ** (1 + self.B) + 3 - var, 2 ** (1 + self.B) + 4]
        for i in on:
            self.slot_ook[i] = 1

    def work(self, input_items, output_items):
        if len(output_items[0]) &gt;= self.slot_width * self.slot_per_buffer:
            if self.nslot == 0:
                self.init_symbol()
                send_slot = self.slot_ook[:self.slot_per_buffer]
            elif self.nslot + self.slot_per_buffer &gt; self.slot_per_symbol:
                temp = self.slot_ook[self.nslot:]
                self.init_symbol()
                send_slot = temp + self.slot_ook[:(self.nslot + self.slot_per_buffer) % self.slot_per_symbol]
            elif self.nslot + self.slot_per_buffer &lt;= self.slot_per_symbol:
                send_slot = self.slot_ook[self.nslot: self.nslot + self.slot_per_buffer]
            output_items[0][:self.slot_width * self.slot_per_buffer] = np.repeat(send_slot, self.slot_width)
            print(send_slot)

            # flagを進める
            self.nslot = (self.nslot + self.slot_per_buffer) % self.slot_per_symbol

            return self.slot_width * self.slot_per_buffer
        else:
            return 0
</value></param>
<param><key>interval_slot</key><value>interval_slot</value></param>
<param><key>slot_per_buffer</key><value>slot_per_buffer</value></param>
<param><key>slot_width</key><value>slot_width</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>200000</value></param>
<param><key>center_freq0</key><value>924000000</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>100</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
