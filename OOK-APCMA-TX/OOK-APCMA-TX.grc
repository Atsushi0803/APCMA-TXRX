options:
  parameters:
    author: Atsushi.N
    generate_options: no_gui
    id: OOK_APCMA_TX
    output_language: python
    title: OOK-APCMA Transmitter
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: interval_slot
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: slot_width
  id: variable
  parameters:
    value: '64'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import random


      ############################### APCMA Transmitter ############################
      class ApcmaTransmitter(gr.sync_block):
          def __init__(self, bits_per_symbol=2, slot_width=400, interval_slot=50):
              gr.sync_block.__init__(
                  self,
                  name='APCMA Modulation',
                  in_sig=None,
                  out_sig=[np.complex64]
              )

              # 各パラメータの決定
              self.bits_per_symbol = bits_per_symbol  # [bits/symbol]
              self.slot_width = slot_width  # [sample]
              self.interval_slot = interval_slot  # シンボル間隔のスロット数 [slot]
              self.slot_per_symbol = 2 ** (1 + self.bits_per_symbol) + 5

              self.nth_slot = 0  # タイムスロットの番号
              self.nth_var = 0  # varをループにするときのindex

              self.slot_ook = [0] * self.slot_per_symbol  # slotのon-offを表すリスト
              self.init_symbol()  # 最初のシンボルを決定

          def decide_var(self, pattern, start_var, end_var):
              if pattern == "random":
                  var = random.randint(start_var, end_var)
              elif pattern == "loop":
                  var_list = list(range(start_var, end_var + 1))
                  var = var_list[self.nth_var]
                  self.nth_var += 1
                  if self.nth_var == len(var_list):
                      self.nth_var = 0
              elif pattern == "static":
                  var = start_var

              # 送信した値varを保存
              # with open('send_data.csv', 'a') as f:
              #     print(var, file=f)
              print(var)
              return var

          def init_symbol(self):
              self.nth_slot = 0
              var = self.decide_var("loop", 1, 4)
              self.slot_ook = [0] * (self.slot_per_symbol + random.randint(self.interval_slot - 5, self.interval_slot + 5))
              on = [0, var + 1, self.slot_per_symbol - 2 - var, self.slot_per_symbol - 1]
              for i in on:
                  self.slot_ook[i] = 0.9

          def work(self, input_items, output_items):
              if len(output_items[0]) > self.slot_width:
                  output_items[0][:self.slot_width] = np.repeat(self.slot_ook[self.nth_slot], self.slot_width)

                  # flagを進める
                  self.nth_slot = self.nth_slot + 1

                  # 1シンボルを送信したあとの処理
                  if self.nth_slot == self.slot_per_symbol:
                      self.init_symbol()

                  return self.slot_width
              else:
                  return 0
    bits_per_symbol: bits_per_symbol
    interval_slot: interval_slot
    slot_width: slot_width
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '50000'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '100000'
    center_freq0: '924000000'
    dev_args: '""'
    gain0: '100'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
