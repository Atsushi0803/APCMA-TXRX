options:
  parameters:
    author: Atsushi.N
    generate_options: qt_gui
    id: OOK_APCMA_TX
    output_language: python
    title: OOK-APCMA Transmitter
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interval_slot
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: slot_per_buffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: slot_width
  id: variable
  parameters:
    value: '400'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: C:\Users\Atsushi.N\Desktop\data.wav
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    B: bits_per_symbol
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport csv\nimport random\n\n\n############################### APCMA Transmitter ############################\nclass blk(gr.sync_block):\n    def __init__(self, B=2, slot_width=400, interval_slot=50, slot_per_buffer=1):\n        gr.sync_block.__init__(\n            self,\n            name='APCMA Modulation',\n            in_sig=None,\n            out_sig=[np.complex64]\n        )\n        \n        self.B = B  # [bit/symbol]\n        self.slot_width = slot_width  # [sample]\n        self.interval_slot = interval_slot  # シンボル間隔のスロット数 [slot]\n        self.slot_per_buffer = slot_per_buffer\n        self.slot_per_symbol = 2 ** (1 + self.B) + 5 + self.interval_slot\n        \n        self.nslot = 0  # タイムスロットの番号、1:2**self.fs +5\n        self.l = 0\n\n        self.init_symbol()\n        \n        \n\n    def decide_var(self, pattern, start_var, end_var):\n        if pattern == \"random\":\n            var = random.randint(start_var, end_var)\n        elif pattern == \"loop\":\n            var_list = list(range(start_var, end_var + 1))\n            var = var_list[self.l]\n            self.l += 1\n            if self.l == len(var_list):\n                self.l = 0\n        elif pattern == \"static\":\n            var = start_var\n\n        # 送信した値varを保存\n        # with open('send_data.csv', 'a') as f:\n        #     print(var, file=f)\n        print(var)\n        return var\n        \n        \n    def init_symbol(self):\n\t    var = self.decide_var(\"loop\", 1, 4)\n\t    self.slot_ook = [0] * self.slot_per_symbol\n\t    on = [0, var+1, 2 ** (1 + self.B) + 3 - var, 2 ** (1 + self.B) + 4]\n\t    for i in on:\n\t\t    self.slot_ook[i] = 1\n\n\n    def work(self, input_items, output_items):\n        if self.slot_per_buffer > self.slot_per_symbol - self.nslot:\n            send_slot = self.slot_ook[self.nslot:]\n            self.init_symbol()\n            send_slot.extend(self.slot_ook[:self.slot_per_buffer-self.slot_per_symbol+self.nslot])\n        elif self.nslot == 0:\n            self.init_symbol()\n            send_slot = self.slot_ook[:self.slot_per_buffer]\n        else:\n            send_slot = self.slot_ook[self.nslot:self.nslot + self.slot_per_buffer]\n\n        # print(send_slot)\n        if len(output_items[0]) >= self.slot_width * self.slot_per_buffer:\n            output_items[0][:self.slot_width * self.slot_per_buffer] = np.repeat(send_slot, self.slot_width)\n            print(send_slot)\n\n            # flagを進める\n            self.nslot = (self.nslot + self.slot_per_buffer) % self.slot_per_symbol\n\n            return self.slot_width * self.slot_per_buffer\n        else:\n            return 0\n\n"
    interval_slot: interval_slot
    slot_per_buffer: slot_per_buffer
    slot_width: slot_width
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '50000'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: '924000000'
    dev_args: '""'
    gain0: '10'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
